# IAR project LCDDemo_GCP.ewp, settings and files
configuration Debug (RL78, debug)
  General.GenDeviceSelect: R5F100LE RL78 - R5F100LE
configuration Release (RL78)
  as the first configuration, except:
  group applilet_src
    applilet3_src/: r_main.c r_systeminit.c r_cgc.c r_cgc_user.c r_port.c r_port_user.c r_serial.c r_serial_user.c r_timer.c r_timer_user.c r_wdt.c r_wdt_user.c r_it.c r_it_user.c
