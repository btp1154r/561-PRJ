# IAR project ProfilerDemo.ewp, settings and files
configuration Debug (RL78, debug)
  General.GenDeviceSelect: R5F100LE RL78 - R5F100LE
  General.GenCodeModel: 0
  General.GenDataModel: 0
  General.GenStackSize: 768
  General.GenNearHeapSize: 512
  General.GenFarHeapSize: 4096
  ICCRL78.IccLang: 0
  ICCRL78.CCIncludePath2: applilet3_src\; Glyph\; Glyph\Drivers\; Glyph\Fonts\; user_include\; RTC\
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnkr5f100le.xcl
  XLINK.XlinkStackSize: 1
configuration Release (RL78)
  as the first configuration, except:
  ICCRL78.CCDefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group applilet_src
    applilet3_src/: diskio.h ff.c ff.h ffconf.h integer.h iodefine.h mmc_spi.c r_cg_cgc.c r_cg_cgc.h r_cg_cgc_user.c r_cg_intc.c r_cg_intc.h r_cg_intc_user.c r_cg_it.c r_cg_it.h r_cg_it_user.c r_cg_macrodriver.h r_cg_port.c r_cg_port.h r_cg_port_user.c r_cg_serial.c r_cg_serial.h r_cg_serial_user.c r_cg_timer.c r_cg_timer.h r_cg_timer_user.c r_cg_userdefine.h r_main.c r_systeminit.c typedefine.h
  group RTC
    RTC/: rtc_sched.c
  group user_include
    user_include/: config.h Geometry.h ior5f100LE.h ior5f100LE_ext.h profile.h proto.h RDKRL78_spi.h Region.h tasks.h
  group user_src
    user_src/: CMAN_coords.c Geometry.c profile.c RDKRL78_spi.c region.c tasks.c
